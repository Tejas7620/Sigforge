options:
  parameters:
    author: SigForge
    description: SigForge Live SDR IQ Streamer via TCP Sink
    generate_options: qt_gui
    id: sigforge_sdr_streamer
    output_language: python
    title: SigForge SDR Live Streamer
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 433.92e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    center_freq0: center_freq
    freq0: center_freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '12345'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', network_tcp_sink_0, '0']

metadata:
  file_format: 1
